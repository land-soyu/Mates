# Keil uVision project ApBoard.uvprojx, settings and files
target Apboard (ARM-ADS)
  device: EFM32JG1B200F256IM48 Silicon Labs
  pack: Keil.EFM32JG1B_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ApBoard
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: EFM32JG1B200F256GM48
  c misc: --C99
  c include: ..\;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\SiliconLabs\EFM32JG1B\Include;..\Drivers\common\drivers;..\Drivers\emlib\inc;..\Drivers\emdrv\common\inc;..\Drivers\emdrv\dmadrv\inc;..\Drivers\emdrv\dmadrv\config;..\Drivers\emdrv\rtcdrv\inc;..\Drivers\emdrv\rtcdrv\config;..\Drivers\emdrv\spidrv\inc;..\Drivers\emdrv\spidrv\config;..\Inc;..\RTT
  asm define: EFM32JG1B200F256GM48
  asm include: ..\;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\SiliconLabs\EFM32JG1B\Include;..\Drivers\common\drivers;..\Drivers\emdrv\common\inc;..\Drivers\emdrv\spidrv\inc;..\Drivers\emdrv\spidrv\config;..\Drivers\emlib\inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Drivers/CMSIS/Device/SiliconLabs/EFM32JG1B/Source/: system_efm32jg1b.c
    ../Drivers/CMSIS/Device/SiliconLabs/EFM32JG1B/Source/ARM/: startup_efm32jg1b.s
  group emlib
    ../Drivers/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_i2c.c em_rtcc.c em_system.c em_usart.c em_letimer.c
  group Drivers
    ../Drivers/common/drivers/: i2cspm.c
  group Source
    ../Src/: main.c MEMS.c api.c sx1276.c system.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
