# Keil uVision project ApBoard.uvprojx, settings and files
target ApBoard (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ApBoard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xB
  c misc: --C99
  c include: ../Inc;           ../Drivers/STM32L1xx_HAL_Driver/Inc;           ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;           ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;           ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Application/User
    ../Src/: stm32l1xx_it.c stm32l1xx_hal_msp.c main.c sx1276.c system.c Timer.c api.c L3G4200D.c
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_flash.c stm32l1xx_hal_cortex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_tim.c stm32l1xx_hal.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_adc.c
software components: CMSIS:CORE 4.1.0
