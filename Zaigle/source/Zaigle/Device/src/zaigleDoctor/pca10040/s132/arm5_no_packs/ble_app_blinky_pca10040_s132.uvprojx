# Keil uVision project ble_app_blinky_pca10040_s132.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --reduce_paths
  c include: ..\..\..\..\..\SDK\components;..\..\..\..\..\SDK\components\ble\ble_advertising;..\..\..\..\..\SDK\components\ble\ble_dtm;..\..\..\..\..\SDK\components\ble\ble_racp;..\..\..\..\..\SDK\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_ans_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_bas;..\..\..\..\..\SDK\components\ble\ble_services\ble_bas_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_cscs;..\..\..\..\..\SDK\components\ble\ble_services\ble_cts_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_dfu;..\..\..\..\..\SDK\components\ble\ble_services\ble_dis;..\..\..\..\..\SDK\components\ble\ble_services\ble_gls;..\..\..\..\..\SDK\components\ble\ble_services\ble_hids;..\..\..\..\..\SDK\components\ble\ble_services\ble_hrs;..\..\..\..\..\SDK\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_hts;..\..\..\..\..\SDK\components\ble\ble_services\ble_ias;..\..\..\..\..\SDK\components\ble\ble_services\ble_ias_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_lbs;..\..\..\..\..\SDK\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_lls;..\..\..\..\..\SDK\components\ble\ble_services\ble_nus;..\..\..\..\..\SDK\components\ble\ble_services\ble_nus_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_rscs;..\..\..\..\..\SDK\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_tps;..\..\..\..\..\SDK\components\ble\common;..\..\..\..\..\SDK\components\ble\nrf_ble_gatt;..\..\..\..\..\SDK\components\ble\nrf_ble_qwr;..\..\..\..\..\SDK\components\ble\peer_manager;..\..\..\..\..\SDK\components\boards;..\..\..\..\..\SDK\components\drivers_nrf\clock;..\..\..\..\..\SDK\components\drivers_nrf\common;..\..\..\..\..\SDK\components\drivers_nrf\comp;..\..\..\..\..\SDK\components\drivers_nrf\delay;..\..\..\..\..\SDK\components\drivers_nrf\gpiote;..\..\..\..\..\SDK\components\drivers_nrf\hal;..\..\..\..\..\SDK\components\drivers_nrf\i2s;..\..\..\..\..\SDK\components\drivers_nrf\lpcomp;..\..\..\..\..\SDK\components\drivers_nrf\pdm;..\..\..\..\..\SDK\components\drivers_nrf\power;..\..\..\..\..\SDK\components\drivers_nrf\ppi;..\..\..\..\..\SDK\components\drivers_nrf\pwm;..\..\..\..\..\SDK\components\drivers_nrf\qdec;..\..\..\..\..\SDK\components\drivers_nrf\rng;..\..\..\..\..\SDK\components\drivers_nrf\rtc;..\..\..\..\..\SDK\components\drivers_nrf\saadc;..\..\..\..\..\SDK\components\drivers_nrf\spi_master;..\..\..\..\..\SDK\components\drivers_nrf\spi_slave;..\..\..\..\..\SDK\components\drivers_nrf\swi;..\..\..\..\..\SDK\components\drivers_nrf\timer;..\..\..\..\..\SDK\components\drivers_nrf\twi_master;..\..\..\..\..\SDK\components\drivers_nrf\twis_slave;..\..\..\..\..\SDK\components\drivers_nrf\uart;..\..\..\..\..\SDK\components\drivers_nrf\usbd;..\..\..\..\..\SDK\components\drivers_nrf\wdt;..\..\..\..\..\SDK\components\libraries\atomic;..\..\..\..\..\SDK\components\libraries\atomic_fifo;..\..\..\..\..\SDK\components\libraries\balloc;..\..\..\..\..\SDK\components\libraries\button;..\..\..\..\..\SDK\components\libraries\crc16;..\..\..\..\..\SDK\components\libraries\crc32;..\..\..\..\..\SDK\components\libraries\csense;..\..\..\..\..\SDK\components\libraries\csense_drv;..\..\..\..\..\SDK\components\libraries\ecc;..\..\..\..\..\SDK\components\libraries\experimental_cli;..\..\..\..\..\SDK\components\libraries\experimental_log;..\..\..\..\..\SDK\components\libraries\experimental_log\src;..\..\..\..\..\SDK\components\libraries\experimental_memobj;..\..\..\..\..\SDK\components\libraries\experimental_section_vars;..\..\..\..\..\SDK\components\libraries\fds;..\..\..\..\..\SDK\components\libraries\fstorage;..\..\..\..\..\SDK\components\libraries\gpiote;..\..\..\..\..\SDK\components\libraries\hardfault;..\..\..\..\..\SDK\components\libraries\hci;..\..\..\..\..\SDK\components\libraries\led_softblink;..\..\..\..\..\SDK\components\libraries\low_power_pwm;..\..\..\..\..\SDK\components\libraries\mem_manager;..\..\..\..\..\SDK\components\libraries\mutex;..\..\..\..\..\SDK\components\libraries\pwm;..\..\..\..\..\SDK\components\libraries\pwr_mgmt;..\..\..\..\..\SDK\components\libraries\queue;..\..\..\..\..\SDK\components\libraries\scheduler;..\..\..\..\..\SDK\components\libraries\slip;..\..\..\..\..\SDK\components\libraries\strerror;..\..\..\..\..\SDK\components\libraries\timer;..\..\..\..\..\SDK\components\libraries\twi;..\..\..\..\..\SDK\components\libraries\uart;..\..\..\..\..\SDK\components\libraries\usbd;..\..\..\..\..\SDK\components\libraries\usbd\class\audio;..\..\..\..\..\SDK\components\libraries\usbd\class\cdc;..\..\..\..\..\SDK\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\SDK\components\libraries\usbd\class\hid;..\..\..\..\..\SDK\components\libraries\usbd\class\hid\generic;..\..\..\..\..\SDK\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\SDK\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\SDK\components\libraries\usbd\class\msc;..\..\..\..\..\SDK\components\libraries\usbd\config;..\..\..\..\..\SDK\components\libraries\util;..\..\..\..\..\SDK\components\softdevice\common;..\..\..\..\..\SDK\components\softdevice\s132\headers;..\..\..\..\..\SDK\components\softdevice\s132\headers\nrf52;..\..\..\..\..\SDK\components\toolchain;..\..\..\..\..\SDK\external\fprintf;..\..\..\..\..\SDK\external\segger_rtt;..\config;..\..\..\OLED;..\..\..\PPG;..\..\..\BMA250;..\..\..\i2c;..\..\..\..\..\SDK\components\drivers_nrf\saadc;..\..\..\..\..\SDK\components\drivers_nrf\timer
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=5,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\..\..\..\..\SDK\components;..\..\..\..\..\SDK\components\ble\ble_advertising;..\..\..\..\..\SDK\components\ble\ble_dtm;..\..\..\..\..\SDK\components\ble\ble_racp;..\..\..\..\..\SDK\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_ans_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_bas;..\..\..\..\..\SDK\components\ble\ble_services\ble_bas_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_cscs;..\..\..\..\..\SDK\components\ble\ble_services\ble_cts_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_dfu;..\..\..\..\..\SDK\components\ble\ble_services\ble_dis;..\..\..\..\..\SDK\components\ble\ble_services\ble_gls;..\..\..\..\..\SDK\components\ble\ble_services\ble_hids;..\..\..\..\..\SDK\components\ble\ble_services\ble_hrs;..\..\..\..\..\SDK\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_hts;..\..\..\..\..\SDK\components\ble\ble_services\ble_ias;..\..\..\..\..\SDK\components\ble\ble_services\ble_ias_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_lbs;..\..\..\..\..\SDK\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_lls;..\..\..\..\..\SDK\components\ble\ble_services\ble_nus;..\..\..\..\..\SDK\components\ble\ble_services\ble_nus_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_rscs;..\..\..\..\..\SDK\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_tps;..\..\..\..\..\SDK\components\ble\common;..\..\..\..\..\SDK\components\ble\nrf_ble_gatt;..\..\..\..\..\SDK\components\ble\nrf_ble_qwr;..\..\..\..\..\SDK\components\ble\peer_manager;..\..\..\..\..\SDK\components\boards;..\..\..\..\..\SDK\components\drivers_nrf\clock;..\..\..\..\..\SDK\components\drivers_nrf\common;..\..\..\..\..\SDK\components\drivers_nrf\comp;..\..\..\..\..\SDK\components\drivers_nrf\delay;..\..\..\..\..\SDK\components\drivers_nrf\gpiote;..\..\..\..\..\SDK\components\drivers_nrf\hal;..\..\..\..\..\SDK\components\drivers_nrf\i2s;..\..\..\..\..\SDK\components\drivers_nrf\lpcomp;..\..\..\..\..\SDK\components\drivers_nrf\pdm;..\..\..\..\..\SDK\components\drivers_nrf\power;..\..\..\..\..\SDK\components\drivers_nrf\ppi;..\..\..\..\..\SDK\components\drivers_nrf\pwm;..\..\..\..\..\SDK\components\drivers_nrf\qdec;..\..\..\..\..\SDK\components\drivers_nrf\rng;..\..\..\..\..\SDK\components\drivers_nrf\rtc;..\..\..\..\..\SDK\components\drivers_nrf\saadc;..\..\..\..\..\SDK\components\drivers_nrf\spi_master;..\..\..\..\..\SDK\components\drivers_nrf\spi_slave;..\..\..\..\..\SDK\components\drivers_nrf\swi;..\..\..\..\..\SDK\components\drivers_nrf\timer;..\..\..\..\..\SDK\components\drivers_nrf\twi_master;..\..\..\..\..\SDK\components\drivers_nrf\twis_slave;..\..\..\..\..\SDK\components\drivers_nrf\uart;..\..\..\..\..\SDK\components\drivers_nrf\usbd;..\..\..\..\..\SDK\components\drivers_nrf\wdt;..\..\..\..\..\SDK\components\libraries\atomic;..\..\..\..\..\SDK\components\libraries\atomic_fifo;..\..\..\..\..\SDK\components\libraries\balloc;..\..\..\..\..\SDK\components\libraries\button;..\..\..\..\..\SDK\components\libraries\crc16;..\..\..\..\..\SDK\components\libraries\crc32;..\..\..\..\..\SDK\components\libraries\csense;..\..\..\..\..\SDK\components\libraries\csense_drv;..\..\..\..\..\SDK\components\libraries\ecc;..\..\..\..\..\SDK\components\libraries\experimental_cli;..\..\..\..\..\SDK\components\libraries\experimental_log;..\..\..\..\..\SDK\components\libraries\experimental_log\src;..\..\..\..\..\SDK\components\libraries\experimental_memobj;..\..\..\..\..\SDK\components\libraries\experimental_section_vars;..\..\..\..\..\SDK\components\libraries\fds;..\..\..\..\..\SDK\components\libraries\fstorage;..\..\..\..\..\SDK\components\libraries\gpiote;..\..\..\..\..\SDK\components\libraries\hardfault;..\..\..\..\..\SDK\components\libraries\hci;..\..\..\..\..\SDK\components\libraries\led_softblink;..\..\..\..\..\SDK\components\libraries\low_power_pwm;..\..\..\..\..\SDK\components\libraries\mem_manager;..\..\..\..\..\SDK\components\libraries\mutex;..\..\..\..\..\SDK\components\libraries\pwm;..\..\..\..\..\SDK\components\libraries\pwr_mgmt;..\..\..\..\..\SDK\components\libraries\queue;..\..\..\..\..\SDK\components\libraries\scheduler;..\..\..\..\..\SDK\components\libraries\slip;..\..\..\..\..\SDK\components\libraries\strerror;..\..\..\..\..\SDK\components\libraries\timer;..\..\..\..\..\SDK\components\libraries\twi;..\..\..\..\..\SDK\components\libraries\uart;..\..\..\..\..\SDK\components\libraries\usbd;..\..\..\..\..\SDK\components\libraries\usbd\class\audio;..\..\..\..\..\SDK\components\libraries\usbd\class\cdc;..\..\..\..\..\SDK\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\SDK\components\libraries\usbd\class\hid;..\..\..\..\..\SDK\components\libraries\usbd\class\hid\generic;..\..\..\..\..\SDK\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\SDK\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\SDK\components\libraries\usbd\class\msc;..\..\..\..\..\SDK\components\libraries\usbd\config;..\..\..\..\..\SDK\components\libraries\util;..\..\..\..\..\SDK\components\softdevice\common;..\..\..\..\..\SDK\components\softdevice\s132\headers;..\..\..\..\..\SDK\components\softdevice\s132\headers\nrf52;..\..\..\..\..\SDK\components\toolchain;..\..\..\..\..\SDK\external\fprintf;..\..\..\..\..\SDK\external\segger_rtt;..\config;..\..\..\OLED;..\..\..\PPG
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x20002180 size 0xde80
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../SDK/components/boards/: boards.c
  group nRF_BLE
    ../../../../../SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../../../SDK/components/ble/ble_services/ble_lbs/: ble_lbs.c
    ../../../../../SDK/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../../SDK/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../SDK/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../SDK/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../SDK/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../SDK/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../../SDK/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../SDK/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../SDK/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../../SDK/components/drivers_nrf/power/: nrf_drv_power.c
    ../../../../../SDK/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../SDK/components/drivers_nrf/hal/: nrf_saadc.c
  group nRF_Libraries
    ../../../../../SDK/components/libraries/button/: app_button.c
    ../../../../../SDK/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../../SDK/components/libraries/scheduler/: app_scheduler.c
    ../../../../../SDK/components/libraries/timer/: app_timer.c
    ../../../../../SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../SDK/components/libraries/balloc/: nrf_balloc.c
    ../../../../../SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../SDK/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../SDK/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../SDK/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nRF_SoftDevice
    ../../../../../SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group i2c
    ../../../i2c/: i2c.c algorithm.c battery.c
target flash_s132_nrf52_5.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: as above
  output: s132_nrf52_5.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c misc: --reduce_paths
  c include: ..\..\..\..\..\SDK\components;..\..\..\..\..\SDK\components\ble\ble_advertising;..\..\..\..\..\SDK\components\ble\ble_dtm;..\..\..\..\..\SDK\components\ble\ble_racp;..\..\..\..\..\SDK\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_ans_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_bas;..\..\..\..\..\SDK\components\ble\ble_services\ble_bas_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\SDK\components\ble\ble_services\ble_dis;..\..\..\..\..\SDK\components\ble\ble_services\ble_gls;..\..\..\..\..\SDK\components\ble\ble_services\ble_hids;..\..\..\..\..\SDK\components\ble\ble_services\ble_hrs;..\..\..\..\..\SDK\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_lbs;..\..\..\..\..\SDK\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_lls;..\..\..\..\..\SDK\components\ble\ble_services\ble_nus;..\..\..\..\..\SDK\components\ble\ble_services\ble_nus_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_rscs;..\..\..\..\..\SDK\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\SDK\components\ble\ble_services\ble_tps;..\..\..\..\..\SDK\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\SDK\components\ble\peer_manager;..\..\..\..\..\SDK\components\boards;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\SDK\components\drivers_nrf\common;..\..\..\..\..\SDK\components\drivers_nrf\comp;..\..\..\..\..\SDK\components\drivers_nrf\delay;..\..\..\..\..\SDK\components\drivers_nrf\gpiote;..\..\..\..\..\SDK\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\SDK\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\SDK\components\drivers_nrf\power;..\..\..\..\..\SDK\components\drivers_nrf\ppi;..\..\..\..\..\SDK\components\drivers_nrf\pwm;..\..\..\..\..\SDK\components\drivers_nrf\qdec;..\..\..\..\..\SDK\components\drivers_nrf\rng;..\..\..\..\..\SDK\components\drivers_nrf\rtc;..\..\..\..\..\SDK\components\drivers_nrf\saadc;..\..\..\..\..\SDK\components\drivers_nrf\spi_master;..\..\..\..\..\SDK\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\SDK\components\drivers_nrf\twi_master;..\..\..\..\..\SDK\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\SDK\components\drivers_nrf\usbd;..\..\..\..\..\SDK\components\drivers_nrf\wdt;..\..\..\..\..\SDK\components\libraries\atomic;..\..\..\..\..\SDK\components\libraries\atomic_fifo;..\..\..\..\..\SDK\components\libraries\balloc;..\..\..\..\..\SDK\components\libraries\button;..\..\..\..\..\SDK\components\libraries\crc16;..\..\..\..\..\SDK\components\libraries\crc32;..\..\..\..\..\SDK\components\libraries\csense;..\..\..\..\..\SDK\components\libraries\csense_drv;..\..\..\..\..\SDK\components\libraries\ecc;..\..\..\..\..\SDK\components\libraries\experimental_cli;..\..\..\..\..\SDK\components\libraries\experimental_log;..\..\..\..\..\SDK\components\libraries\experimental_log\src;..\..\..\..\..\SDK\components\libraries\experimental_memobj;..\..\..\..\..\SDK\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\SDK\components\libraries\fstorage;..\..\..\..\..\SDK\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\SDK\components\libraries\hci;..\..\..\..\..\SDK\components\libraries\led_softblink;..\..\..\..\..\SDK\components\libraries\low_power_pwm;..\..\..\..\..\SDK\components\libraries\mem_manager;..\..\..\..\..\SDK\components\libraries\mutex;..\..\..\..\..\SDK\components\libraries\pwm;..\..\..\..\..\SDK\components\libraries\pwr_mgmt;..\..\..\..\..\SDK\components\libraries\queue;..\..\..\..\..\SDK\components\libraries\scheduler;..\..\..\..\..\SDK\components\libraries\slip;..\..\..\..\..\SDK\components\libraries\strerror;..\..\..\..\..\SDK\components\libraries\timer;..\..\..\..\..\SDK\components\libraries\twi;..\..\..\..\..\SDK\components\libraries\uart;..\..\..\..\..\SDK\components\libraries\usbd;..\..\..\..\..\SDK\components\libraries\usbd\class\audio;..\..\..\..\..\SDK\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\SDK\components\libraries\usbd\class\hid;..\..\..\..\..\SDK\components\libraries\usbd\class\hid\generic;..\..\..\..\..\SDK\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\SDK\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\SDK\components\libraries\usbd\class\msc;..\..\..\..\..\SDK\components\libraries\usbd\config;..\..\..\..\..\SDK\components\libraries\util;..\..\..\..\..\SDK\components\softdevice\common;..\..\..\..\..\SDK\components\softdevice\s132\headers;..\..\..\..\..\SDK\components\softdevice\s132\headers\nrf52;..\..\..\..\..\SDK\components\toolchain;..\..\..\..\..\SDK\external\fprintf;..\..\..\..\..\SDK\external\segger_rtt;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x20002180 size 0xde80
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.0.2, CMSIS:CORE 4.3.0, Device:Startup 8.14.1, Device:Startup 8.15.0, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_gpiote 4.0.0-2.alpha
